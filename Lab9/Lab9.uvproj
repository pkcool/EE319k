# Keil uVision project Lab9.uvproj, settings and files
target Lab9 (ARM-ADS)
  device: LM3S1968 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: Lab9
  c flags: Optim=1
  c include: ..;..\..\..;..\inc;..\driverlib
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Code
    ./: Startup.s ADCDriver.c LCD2.s Lab9.c SysTick.c PLL.c Output.c rit128x96x4.c UART.c
  group Library
    ../driverlib/rvmdk/: driverlib.lib
