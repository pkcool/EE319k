# Keil uVision project Game.uvproj, settings and files
target Game (ARM-ADS)
  device: LM3S1968 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: Game
  c flags: Optim=4 OneElfS=1
  c include: ..;..\..\..;..\inc;..\driverlib
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Code
    ./: main.c maze.c random.c Startup.s SysTick.c PLL.c ADCDriver.c Game.c Graphics.c Input.c Timer.c Sound.c DAC.c
    ../drivers/: rit128x96x4.c
  group Library
    ../driverlib/rvmdk/: driverlib.lib
